# Keil uVision project Motor Sheild Module_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: Motor Sheild Module_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h Pin_1_aliases.h Pin_1.c Pin_1.h Pin_2_aliases.h Pin_2.c Pin_2.h Pin_3_aliases.h Pin_3.c Pin_3.h Pin_4_aliases.h Pin_4.c Pin_4.h Clock_1.c Clock_1.h Motor_1_PWM_2.c Motor_1_PWM_2.h Motor_1_PWM_2_PM.c Motor_1_PWM_3.c Motor_1_PWM_3.h Motor_1_PWM_3_PM.c Motor_1_PWM_4.c Motor_1_PWM_4.h Motor_1_PWM_4_PM.c Motor_1_PWM_5.c Motor_1_PWM_5.h Motor_1_PWM_5_PM.c Motor_1_PWM_6.c Motor_1_PWM_6.h Motor_1_PWM_6_PM.c Motor_1_PWM_7.c Motor_1_PWM_7.h Motor_1_PWM_7_PM.c Motor_1_PWM_8.c Motor_1_PWM_8.h Motor_1_PWM_8_PM.c Motor_1_PWM_1.c Motor_1_PWM_1.h Motor_1_PWM_1_PM.c cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h Motor_1_Control_Reg_1.c Motor_1_Control_Reg_1.h Motor_1_Status_Reg_1.c Motor_1_Status_Reg_1.h Motor_1_function.c Motor_1_function.h Motor_1_PWM_9.c Motor_1_PWM_9.h Motor_1_PWM_9_PM.c Motor_1_PWM_10.c Motor_1_PWM_10.h Motor_1_PWM_10_PM.c Motor_1_PWM_11.c Motor_1_PWM_11.h Motor_1_PWM_11_PM.c Motor_1_PWM_12.c Motor_1_PWM_12.h Motor_1_PWM_12_PM.c Motor_1_PWM_13.c Motor_1_PWM_13.h Motor_1_PWM_13_PM.c Motor_1_PWM_14.c Motor_1_PWM_14.h Motor_1_PWM_14_PM.c Motor_1_PWM_15.c Motor_1_PWM_15.h Motor_1_PWM_15_PM.c Motor_1_PWM_16.c Motor_1_PWM_16.h Motor_1_PWM_16_PM.c Motor_1_Timer_1.c Motor_1_Timer_1.h Motor_1_Timer_1_PM.c
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: Motor Sheild Module_PSoC5lib (library)
